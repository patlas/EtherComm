# Keil uVision project ksdk_hal_lib.uvproj, settings and files
target ksdk_hal_lib Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: ksdk_hal_lib.lib (library)
  c flags: Optim=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, KEIL
  c misc: --library_interface=armcc  --library_type=standardlib --c99 --diag_suppress=1296,186
  c include: ../../../../platform/CMSIS/Include;../../../../platform/CMSIS/Include/device;../../../../platform/startup/MK64F12;../../../../platform/utilities;../../../../platform/hal/sim
  asm define: DEBUG
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group platform-hal-adc
    ../../../../platform/hal/adc/: fsl_adc_features.h fsl_adc_hal.c fsl_adc_hal.h
  group platform-hal-can
    ../../../../platform/hal/can/: fsl_flexcan_features.h fsl_flexcan_hal.c fsl_flexcan_hal.h
  group platform-hal-dac
    ../../../../platform/hal/dac/: fsl_dac_features.h fsl_dac_hal.c fsl_dac_hal.h
  group platform-hal-dmamux
    ../../../../platform/hal/dmamux/: fsl_dmamux_hal.c fsl_dmamux_hal.h fsl_dmamux_features.h
  group platform-hal-edma
    ../../../../platform/hal/edma/: fsl_edma_features.h fsl_edma_hal.h fsl_edma_hal.c
  group platform-hal-enet
    ../../../../platform/hal/enet/: fsl_enet_features.h fsl_enet_hal.c fsl_enet_hal.h
  group platform-hal-dspi
    ../../../../platform/hal/dspi/: fsl_dspi_features.h fsl_dspi_hal.c fsl_dspi_hal.h
  group platform-hal-flextimer
    ../../../../platform/hal/flextimer/: fsl_ftm_features.h fsl_ftm_hal.c fsl_ftm_hal.h
  group platform-hal-gpio
    ../../../../platform/hal/gpio/: fsl_gpio_features.h fsl_gpio_hal.c fsl_gpio_hal.h
  group platform-hal-i2c
    ../../../../platform/hal/i2c/: fsl_i2c_features.h fsl_i2c_hal.c fsl_i2c_hal.h
  group platform-hal-llwu
    ../../../../platform/hal/llwu/: fsl_llwu_features.h fsl_llwu_hal.c fsl_llwu_hal.h
  group platform-hal-lptmr
    ../../../../platform/hal/lptmr/: fsl_lptmr_features.h fsl_lptmr_hal.c fsl_lptmr_hal.h
  group platform-hal-mpu
    ../../../../platform/hal/mpu/: fsl_mpu_features.h fsl_mpu_hal.c fsl_mpu_hal.h
  group platform-hal-mcg
    ../../../../platform/hal/mcg/: fsl_mcg_features.h fsl_mcg_hal.c fsl_mcg_hal.h fsl_mcg_hal_modes.c fsl_mcg_hal_modes.h
  group platform-hal-osc
    ../../../../platform/hal/osc/: fsl_osc_features.h fsl_osc_hal.c fsl_osc_hal.h
  group platform-hal-pdb
    ../../../../platform/hal/pdb/: fsl_pdb_features.h fsl_pdb_hal.c fsl_pdb_hal.h
  group platform-hal-pit
    ../../../../platform/hal/pit/: fsl_pit_features.h fsl_pit_hal.c fsl_pit_hal.h
  group platform-hal-port
    ../../../../platform/hal/port/: fsl_port_features.h fsl_port_hal.c fsl_port_hal.h
  group platform-hal-rtc
    ../../../../platform/hal/rtc/: fsl_rtc_features.h fsl_rtc_hal.c fsl_rtc_hal.h fsl_rtc_hal_access_control.h fsl_rtc_hal_monotonic.h
  group platform-hal-sai
    ../../../../platform/drivers/sai/hal/: fsl_sai_features.h
    ../../../../platform/hal/sai/: fsl_sai_hal.c fsl_sai_hal.h
  group platform-hal-sdhc
    ../../../../platform/hal/sdhc/: fsl_sdhc_features.h fsl_sdhc_hal.h fsl_sdhc_hal.c
  group platform-hal-sim
    ../../../../platform/hal/sim/MK64F12/: fsl_sim_hal_K64F12.c
    ../../../../platform/hal/sim/: fsl_sim_features.h fsl_sim_hal.c fsl_sim_hal.h
  group platform-hal-smc
    ../../../../platform/hal/smc/: fsl_smc_features.h fsl_smc_hal.c fsl_smc_hal.h
  group platform-hal-uart
    ../../../../platform/hal/uart/: fsl_uart_features.h fsl_uart_hal.h fsl_uart_hal.c
  group platform-hal-wdog
    ../../../../platform/hal/wdog/: fsl_wdog_features.h fsl_wdog_hal.c fsl_wdog_hal.h
  group platform-hal-pmc
    ../../../../platform/hal/pmc/: fsl_pmc_features.h fsl_pmc_hal.c fsl_pmc_hal.h
  group platform-hal-rcm
    ../../../../platform/hal/rcm/: fsl_rcm_features.h fsl_rcm_hal.c fsl_rcm_hal.h
target ksdk_hal_lib Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  output: ksdk_hal_lib.lib (library)
  c flags: Optim=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12, KEIL
  c misc: as above
  c include: as above
  asm misc: --cpreproc --diag_suppress=1609,1581
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
