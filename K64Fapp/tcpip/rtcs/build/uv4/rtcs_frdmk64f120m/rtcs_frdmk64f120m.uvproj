# Keil uVision project rtcs_frdmk64f120m.uvproj, settings and files
target rtcs_frdmk64f120m Debug (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: rtcs.lib (library)
  AfterMake: ../../bat/rtcs_frdmk64f120m.bat ../../.. ../../../lib/frdmk64f120m.uv4/debug/rtcs uv4
  c flags: Optim=1 OneElfS=1
  c define: CPU_MK64FN1M0VMD12=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, _DEBUG=1
  c misc: -J../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/rv_uv4 
-J../../../source/apps 
-J../../../source/if 
-J../../../source/include 
-J../../../source/media 
-J../../../../../rtos/mqx/mqx/source/bsp/K64F12 
-J../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../rtos/mqx/mqx/source/include 
-J../../../../../rtos/mqx/config/common 
-J../../../../../rtos/mqx/mqx/source/tad 
-J../../../../../rtos/mqx/mqx_stdlib/source/include 
-J../../../../../rtos/mqx/mqx/source/nio 
-J../../../../../rtos/mqx/mqx/source 
-J../../../../../rtos/mqx/mqx/source/nio/fs 
-J../../../../../rtos/mqx/mqx/source/psp/cortex_m 
-J../../../../../rtos/mqx/mqx/source/psp/cortex_m/core/M4 
-J../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu 
-J../../../../../rtos/mqx/config/mcu/mk64f120m 
-J../../../../../platform/startup/MK64F12 
-J../../../../../boards/common/phyksz8041 
-J../../../source/nat 
-J../../../source/os 
-J../../../source/ppp 
-J../../../../../platform/drivers/clock 
-J../../../../../platform/drivers/dma 
-J../../../../../platform/drivers/gpio 
-J../../../../../platform/drivers/enet 
-J../../../../../platform/drivers/interrupt 
-J../../../../../platform/drivers/lpuart 
-J../../../../../platform/drivers/mmcau 
-J../../../../../platform/drivers/rtc 
-J../../../../../platform/drivers/smc 
-J../../../../../platform/drivers/uart 
-J../../../../../platform/drivers/wdog 
-J../../../../../platform/system/hwtimer 
-J../../../../../platform/system/clock 
-J../../../../../platform/system/interrupt 
-J../../../../../platform/hal/gpio 
-J../../../../../platform/hal/enet 
-J../../../../../platform/hal/mcg 
-J../../../../../platform/hal/osc 
-J../../../../../platform/hal/port 
-J../../../../../platform/hal/pit 
-J../../../../../platform/hal/pmc 
-J../../../../../platform/hal/rtc 
-J../../../../../platform/hal/sim 
-J../../../../../platform/hal/smc 
-J../../../../../platform/hal/uart 
-J../../../../../platform/hal/wdog 
-J../../../../../platform/osa 
-J../../../../../boards/frdmk64f120m 
-J../../../../../platform 
-J../../../../../platform/CMSIS/Include 
-J../../../../../platform/CMSIS/Include/device 
-J../../../../../platform/utilities 
-J../../../../../rtos 
-J../../../../../filesystem/mfs/source/include 
-J../../../../../rtos/mqx/nshell/source/include 
-J../../../source/snmp 
-J../../../source/tcpip 
-J#J 
--library_interface=none 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../rtos/mqx/mqx/source/psp/cortex_m/compiler/rv_uv4;../../../source/apps;../../../source/if;../../../source/include;../../../source/media;../../../../../rtos/mqx/mqx/source/bsp/K64F12;../../../../../rtos/mqx/mqx/source/bsp;../../../../../rtos/mqx/mqx/source/include;../../../../../rtos/mqx/config/common;../../../../../rtos/mqx/mqx/source/tad;../../../../../rtos/mqx/mqx_stdlib/source/include;../../../../../rtos/mqx/mqx/source/nio;../../../../../rtos/mqx/mqx/source;../../../../../rtos/mqx/mqx/source/nio/fs;../../../../../rtos/mqx/mqx/source/psp/cortex_m;../../../../../rtos/mqx/mqx/source/psp/cortex_m/core/M4;../../../../../rtos/mqx/mqx/source/psp/cortex_m/cpu;../../../../../rtos/mqx/config/mcu/mk64f120m;../../../../../platform/startup/MK64F12;../../../../../boards/common/phyksz8041;../../../source/nat;../../../source/os;../../../source/ppp;../../../../../platform/drivers/clock;../../../../../platform/drivers/dma;../../../../../platform/drivers/gpio;../../../../../platform/drivers/enet;../../../../../platform/drivers/interrupt;../../../../../platform/drivers/lpuart;../../../../../platform/drivers/mmcau;../../../../../platform/drivers/rtc;../../../../../platform/drivers/smc;../../../../../platform/drivers/uart;../../../../../platform/drivers/wdog;../../../../../platform/system/hwtimer;../../../../../platform/system/clock;../../../../../platform/system/interrupt;../../../../../platform/hal/gpio;../../../../../platform/hal/enet;../../../../../platform/hal/mcg;../../../../../platform/hal/osc;../../../../../platform/hal/port;../../../../../platform/hal/pit;../../../../../platform/hal/pmc;../../../../../platform/hal/rtc;../../../../../platform/hal/sim;../../../../../platform/hal/smc;../../../../../platform/hal/uart;../../../../../platform/hal/wdog;../../../../../platform/osa;../../../../../boards/frdmk64f120m;../../../../../platform;../../../../../platform/CMSIS/Include;../../../../../platform/CMSIS/Include/device;../../../../../platform/utilities;../../../../../rtos;../../../../../filesystem/mfs/source/include;../../../../../rtos/mqx/nshell/source/include;../../../source/snmp;../../../source/tcpip
  asm define: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
  group RTCS Source/apps
    ../../../source/apps/: dhcpsrv.c dnscln.c echosrv.c ftpc.c ftpc_cmd.c ftpclnt.c ftpsrv.c ftpsrv_cmd.c ftpsrv_cmd_file.c ftpsrv_cmd_transfer.c ftpsrv_msg.c ftpsrv_supp.c ftpsrv_task.c httpsrv.c httpsrv_script.c httpsrv_supp.c httpsrv_task.c httpsrv_ws.c httpsrv_ws_api.c httpsrv_ws_plugin.c rtcs_base64.c rtcs_sha1.c rtcs_smtp.c rtcs_ssl.c rtcs_utf8.c sntp.c sockio.c telnet.c telnetio.c telnsrv.c tftp.c tftpacc.c tftpsrv.c tftputil.c
  group RTCS Enet driver
    ../../../../../platform/drivers/enet/src/: fsl_enet_rtcs_adapter.c
    ../../../../../boards/common/phyksz8041/: fsl_phy_driver.h fsl_phy_driver.c
  group RTCS Source/if
    ../../../source/if/: arpcmd.c getaddrinfo.c getnameinfo.c ifbootp.c ifdhcp.c ifppp.c ifstat.c iftraps.c iftunnel.c inet.c inet_ntop.c inet_pton.c ipcfg.c ipcfg6.c iwcfg.c ping.c ping6.c rtcs.c rtcs_hosts.c rtcs_if.c rtcscmd.c rtcsdela.c rtcsglob.c rtcsinit.c rtcslog0.c rtcslog1.c rtcsrand.c sdgram.c sock_select.c sockutil.c soigmp.c soip.c solink.c sosock.c sotcp.c soudp.c sstream.c
  group RTCS Include
    ../../../source/include/: arp.h arp_prv.h arpif.h asn1.h bootp.h ccp.h chap.h checksum.h dhcp.h dhcp_prv.h dhcpsrv.h dhcpuprv.h dnscln.h fcs16.h ftpc.h ftpsrv.h ftpsrv_msg.h ftpsrv_prv.h httpsrv.h httpsrv_prv.h httpsrv_supp.h icmp.h icmp_prv.h httpsrv_ws_prv.h httpsrv_plugins.h httpsrv_script.h httpsrv_ws.h iwcfg.h rip_prv.h rtcs_base64.h rtcs_sha1.h rtcs_utf8.h rtcsbios.h igmp.h ip.h ip_prv.h ip_if.h ipcfg.h ipcfg_prv.h ip-e.h ipcp.h ipradix.h iptunnel.h lcp.h md5.h nat.h nat_prv.h nat_session.h natvers.h pap.h ppp.h ppp_prv.h pppfsm.h ppphdlc.h rip.h route.h rtcs.h rtcs_sock.h rtcs_ssl.h rtcs_err.h rtcs_stats.h rtcs_if.h rtcs_hosts.h rtcs_assert.h echosrv.h rtcs_in.h rtcs_prv.h rtcs_smtp.h rtcs25x.h rtcscfg.h rtcslog.h rtcspcb.h rtcsrtos.h rtcstime.h rtcsvers.h snmp.h snmpcfg.h socket.h tcp.h tcp_prv.h tcpip.h telnet.h tftp.h ticker.h udp.h udp_prv.h icmp6.h icmp6_prv.h ip6.h ip6_if.h ip6_prv.h ip6_trace.h nd6.h mld.h addrinfo.h
  group RTCS Source/media
    ../../../source/media/: arp.c arpinit.c ip-e.c ipcp.c ipcpfsm.c proxyarp.c
  group RTCS Source/nat
    ../../../source/nat/: alggen.c dnat.c ifdnat.c ifnat.c nat.c nat_apply.c natalg.c natdata.c natevent.c natftp.c nattftp.c sonat.c
  group RTCS Source/os
    ../../../source/os/mqx/: rtcsdate.c rtcsmsec.c rtcsmsg.c rtcspart.c rtcssec.c rtcstask.c
  group RTCS Source/ppp
    ../../../source/ppp/: ccp.c chap.c gen16.c genmd5.c lcp.c md5.c md5step.c pap.c pktrx.c pkttx.c ppp.c pppfsm.c pppglob.c ppphdlc.c
  group Shell Commands Source
    ../../../../../rtos/mqx/nshell/source/rtcs/: sh_arpdisp.c sh_clock.c sh_echosrv.c sh_enet.c sh_ftpc.c sh_ftpd.c sh_gate.c sh_getname.c sh_getroute.c sh_ghbn.c sh_ipconfig.c sh_iwconfig.c sh_nat.c sh_nstat.c sh_ping.c sh_ppp.c sh_rtcs.c sh_sendto.c sh_smtp.c sh_snmpd.c sh_tftp.c sh_tftpd.c sh_tnet.c sh_tnetd.c
  group RTCS Source/snmp
    ../../../source/snmp/: 1213.c mib.c mqxmib.c snmp.c trap_receivers.c traps.c
  group RTCS Source/tcpip
    ../../../source/tcpip/: bootcomm.c bootinit.c bootp.c checksum.c dhcpclnt.c dhcputil.c icmp.c igmp.c igmputil.c ip.c ip_reasm.c ip_if.c iplocal.c ipradix.c iproute.c iptunnel.c iputil.c rip.c route.c rtcspcb.c tcp.c tcp_buf.c tcp_clos.c tcp_rcv.c tcp_send.c tcpip.c ticker.c timer.c udp.c
target rtcs_frdmk64f120m Release (ARM-ADS)
  device: MK60N512VMD100 Freescale Semiconductor
  cpu: as above
  output: rtcs.lib (library)
  AfterMake: ../../bat/rtcs_frdmk64f120m.bat ../../.. ../../../lib/frdmk64f120m.uv4/release/rtcs uv4
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK64FN1M0VMD12=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm define: as above
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: ..\..\..\lib\twrk60n512.uv4\mqx\intflash.scf
